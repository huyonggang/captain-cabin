# Keil uVision project CatchXBlack_Pro.uvprojx, settings and files
target Primary (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: APM32F407RG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.11
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apm32f407 +hex
  AfterMake: fromelf --bin -o ../../Output/BIN/B_CatchX_Max_Rogue_Max_20260929_V1.01.42.bin ../../Output/apm32f407.axf
  AfterMake: merge.bat "B_CatchX_Max_Rogue_Max_20260929_V1.01.42"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APM32F40X
  c misc: --diag_suppress=68,111,188,223,546,1295 --no-multibyte-chars
  c include: ..\..\Drivers\CMSIS\Include;..\..\Middlewares;..\..\Drivers;..\..\User;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\Drivers\APM32F4xx_StdPeriphDriver\inc;..\..\Drivers\CMSIS\Geehy\APM32F4xx\Include;..\..\Middlewares\RTT;..\..\Drivers\BSP\src;..\..\Drivers\BSP\interface;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\usart;..\..\Middlewares\MAVLINK;..\..\Middlewares\MAVLINK\common;..\..\Middlewares\MAVLINK\minimal;..\..\Drivers\img;..\..\Middlewares\LVGL\examples\porting;..\..\Middlewares\LVGL;..\..\Middlewares\LVGL\src
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\apm32f407.sct
  group Startup
    ../../Drivers/CMSIS/Geehy/APM32F4xx/Source/arm/: startup_apm32f40x.s
  group User
    ../../User/: main.c apm32f4xx_int.c debug_assert.c
    ../../Drivers/CMSIS/Geehy/APM32F4xx/Source/: system_apm32f4xx.c
  group IMG
    ../../Drivers/img/: boat_mini.c CatchX_BS.c Compass.c home.c light.c navigation.c remote_boat.c rssi.c satellite.c speed.c CatchX_BS_ch.c pointA_24_24.c pointB_24_24.c signal05.c link.c rocker.c rocker_1.c rocker_2.c ABPoint.c anchor_icon.c custom.c Earth_icon.c exit_icon.c remote_icon.c reset_icon.c screen_icon.c version_icon.c WiFi_BT_Switch.c ArrowLeft_icon.c Close_icon.c Arrow_left_L.c Radio_off_icon.c Radio_on_icon.c SetID_Colse_icon.c SetID_OK_icon.c Rocker_img.c Check_img.c Colse_img.c change_1_img.c Rippton_log.c Homepoint.c Attention.c HomeBig_img.c icon_charging.c anchor_img.c anchor1_img.c Fram_img.c pointA_48_48.c pointB_48_48.c task_img.c logo.c Homepoint48_48.c lowpower_img.c fish_point_img.c cruise_img.c speed_icon.c CatchX_mini.c wuwei.c yutantan.c boat_mini_img.c spot_1.c spot_2.c spot_3.c spot_4.c spot_5.c spot_6.c spot_7.c spot_8.c spot_9.c spot_10.c spot_11.c spot_12.c spot_13.c spot_14.c spot_15.c spot_16.c spot_17.c spot_18.c spot_19.c spot_20.c intrepid_log.c light_icon.c NoSaveA_icon.c NoSaveB_icon.c R_icon.c SaveA_icon.c SaveB_icon.c arrow1_icon.c arrow2_icon.c NoSaveC_icon.c NoSaveD_icon.c PointA_80_80.c PointB_80_80.c PointC_48_48.c PointC_80_80.c PointD_48_48.c PointD_80_80.c SaveC_icon.c SaveD_icon.c reposition.c spot_task.c continue_img.c pair_img.c Boat_fix.c Line_return.c spot_a_green_l.c spot_b_green_l.c spot_c_green_l.c spot_d_green_l.c Circle.c speed_high.c speed_high_s.c speed_low.c speed_low_s.c speed_medium.c speed_medium_s.c Trash.c speed_auto.c enter_img.c start_img.c switch_img.c ghost_icon.c icon_phone.c icon_remote.c taskbeam.c ghost_max_icon1.c ghost_max_icon2.c git_test.c logo_gif.c ROGUE_MAX.c icon_alert_s.c icon_alert_xl.c icon_shield.c CATCHX_ULTRA_CH_ICON.c CATCHX_ULTRA_ICON.c boat_rogue_fixed.c boat_rogue_nor.c Rogue_SparkMax.c Rogue_SparkMax_cn.c
  group FONT
    ../../Drivers/font/: font_blod_14.c font_blod_16.c font_blod_18.c font_blod_20.c font_blod_22.c font_14.c font_16.c font_18.c font_20.c font_22.c font_34.c font_blod_34.c font_blod_43.c font_12.c font_24.c font_26.c font_blod_12.c font_blod_24.c font_blod_26.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
    ../../Drivers/SYSTEM/delay/: delay.c
  group Drivers/APM32F4xx_Driver
    ../../Drivers/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_comp.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_qspi.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_wwdt.c
  group Drivers/BSP
    ../../Drivers/BSP/src/: led.c key.c exti.c adc.c config_param.c apm32flash.c display.c joystick.c Time.c main_ui.c lcd_init.c spi.c lcd.c menu.c setIDui.c joystickCalib_ui.c My_Queue.c bsp_i2c_gpio.c bsp_i2c_eeprom_24xx.c
  group MAVLINK
    ../../Middlewares/MAVLINK/: mavlink.c
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/lvgl/examples/porting
    ../../Middlewares/LVGL/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group Middlewares/lvgl/src/core
    ../../Middlewares/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/lvgl/src/draw
    ../../Middlewares/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Middlewares/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group Middlewares/lvgl/src/extra
    ../../Middlewares/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../../Middlewares/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../../Middlewares/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../../Middlewares/LVGL/src/extra/others/monkey/: lv_monkey.c
    ../../Middlewares/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../../Middlewares/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../../Middlewares/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../../Middlewares/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../../Middlewares/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../../Middlewares/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Middlewares/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../../Middlewares/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Middlewares/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Middlewares/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Middlewares/LVGL/src/extra/widgets/led/: lv_led.c
    ../../Middlewares/LVGL/src/extra/widgets/list/: lv_list.c
    ../../Middlewares/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../../Middlewares/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../../Middlewares/LVGL/src/extra/widgets/span/: lv_span.c
    ../../Middlewares/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Middlewares/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../../Middlewares/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../../Middlewares/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../../Middlewares/LVGL/src/extra/widgets/win/: lv_win.c
    ../../Middlewares/LVGL/src/extra/: lv_extra.c
    ../../Middlewares/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Middlewares/LVGL/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
  group Middlewares/lvgl/src/font
    ../../Middlewares/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/lvgl/src/gpu
    ../../Middlewares/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../Middlewares/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group Middlewares/lvgl/src/hal
    ../../Middlewares/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/lvgl/src/misc
    ../../Middlewares/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/lvgl/src/widgets
    ../../Middlewares/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/RTT
    ../../Middlewares/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
